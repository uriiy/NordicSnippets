# Keil uVision project i2s_master.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.32.1
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x00800000,0x00040000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: example +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\i2c_master
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x800000 size 0x40000
  scatter file: .\Objects\example.sct
  group Source Group 1
    ../: main.c ssd1306.c
software components: CMSIS:CORE 5.4.0, Device:Startup 8.32.1
